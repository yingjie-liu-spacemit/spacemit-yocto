SUMMARY = "Minimal K1 image with systemd and overlay support"
LICENSE = "MIT"

inherit core-image

require recipes-core/images/include/k1-image.inc
